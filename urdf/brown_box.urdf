Commit message: ready for ablation study

File: urdf/brown_box.urdf (robot description, URDF)
Before this commit: robot brown_box, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.26 0.26 0.01; visual box size=0.16 0.16 0.01
