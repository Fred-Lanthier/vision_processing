Commit message: Improved pick and place policy

File: urdf/red_cube.urdf (robot description, URDF)
Before this commit: robot red_cube, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.04 0.04 0.04; visual box size=0.04 0.04 0.04
